# Keil uVision project ArmServoController.uvprojx, settings and files
target ArmServoController (6210000::V6.21::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x24000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(240000000) ELITTLE
  output: ArmServoController +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H723xx,USE_HAL_DRIVER
  c misc: -mfpu=fpv5-d16 -mfloat-abi=hard
  c include: Core\Inc;app\include;bsp\include;drivers\servo;drivers\ws2812;config;external\STM32CubeH7\Drivers\STM32H7xx_HAL_Driver\Inc;external\STM32CubeH7\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;external\STM32CubeH7\Drivers\CMSIS\Device\ST\STM32H7xx\Include;external\STM32CubeH7\Drivers\CMSIS\Include;external\FreeRTOS-Kernel\include;external\FreeRTOS-Kernel\portable\GCC\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x50000
  group Application
    Core/Src/: main.c stm32h7xx_it.c
    app/source/: app_freertos.c app_servo_test.c
    bsp/source/: bsp_board.c
    drivers/ws2812/: ws2812.c ws2812_palette.c
    drivers/servo/: scs_protocol.c sm30bl.c
    external/STM32CubeH7/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    external/STM32CubeH7/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h723xx.s
  group STM32H7 HAL
    external/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group FreeRTOS
    external/FreeRTOS-Kernel/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    external/FreeRTOS-Kernel/portable/GCC/ARM_CM7/r0p1/: port.c
    external/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
